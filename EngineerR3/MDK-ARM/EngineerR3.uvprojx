# Keil uVision project EngineerR3.uvprojx, settings and files
target EngineerR3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: EngineerR3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__FPU_PRESENT=1,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Drivers/STM32F4xx_HAL_Driver/Inc;C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Middlewares/Third_Party/FreeRTOS/Source/include;C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Drivers/CMSIS/Device/ST/STM32F4xx/Include;C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Drivers/CMSIS/Include;../APPLICATION;../BSP;../MODULE;../BSP/CAN;../BSP/DWT;../BSP/USART;../MODULE/algorithm;../MODULE/C_comm;../MODULE/daemon;../MODULE/imu;../MODULE/motor;../MODULE/remote;../MODULE/motor/DJImotor;../MODULE/motor/DMmotor;C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../APPLICATION/chassis;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/DSP/Include/dsp
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/11737/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.2/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP
    ../BSP/: bsp_gpio.c bsp_pwm.c
    ../BSP/CAN/: bsp_can.c
    ../BSP/DWT/: bsp_dwt.c
    ../BSP/USART/: bsp_usart.c
  group MODULE
    ../MODULE/: bujin.c feite_motor.c MD_tuiqiu.c miniPC_process.c shoot_ex.c
    ../MODULE/remote/: remote.c
    ../MODULE/motor/DMmotor/: dmmotor.c
    ../MODULE/motor/DJImotor/: DJI_motor.c
    ../MODULE/motor/: motor_task.c
    ../MODULE/imu/: BMI088driver.c BMI088Middleware.c ins_task.c
    ../MODULE/daemon/: daemon.c
    ../MODULE/algorithm/: user_lib.c ramp_contorller.c QuaternionEKF.c kalman_filter.c crc16.c crc8.c controller.c
  group APPLICATION
    ../APPLICATION/: dribble.c path.c shoot.c Test.c tuiqiu.c
    ../APPLICATION/chassis/: chassis.c
  group CMSIS_DSP
    ../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: CommonTables.c
software components: CMSIS:CORE 4.3.0
